# Keil uVision project Main_Control_Node.uvprojx, settings and files
target Main (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Main_Control_Node
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Peripherals\virtual_com;..\Peripherals\CAN;.\Drivers\CMSIS\Include;.\Drivers\CMSIS\Device\ST\STM32F1xx\Include;.\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;.\Drivers\STM32F1xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./src/: main.c
  group Peripherals
    ../Peripherals/CAN/: CAN.h CAN.c
    ../Peripherals/virtual_com/: virtual_com.h virtual_com.c
    ../Peripherals/RTC/: RTC.c RTC.h
  group LCD
    ./src/LCD/: LCD.c LCD.h
  group XBee
    ./src/XBee/: XBee.c XBee.h
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS:Keil RTX 4.81.1, Device:Startup 1.0.0
